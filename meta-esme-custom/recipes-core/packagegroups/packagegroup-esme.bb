DESCRIPTION = "esme packagegroup"

inherit packagegroup

RDEPENDS:${PN}-custom = "esme-gpio-toggle"
